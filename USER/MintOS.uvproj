# Keil uVision project MintOS.uvproj, settings and files
target MintOS (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MintOS
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\FWLIB\inc;..\CMSIS;..\MintOS;..\USER;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ../BSP/: bsp.c led.c usart1.c usart2.c
  group OS Task
    ../APP/: m_app.c m_app.h m_app_cfg.h
  group OS Port
    ../MintOS/: m_port.h m_port_a.s m_port.c
  group OS Source
    ../MintOS/: m_os.h m_os_cfg.h m_task.c m_time.c m_mem.c m_core.c
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../STARTUP/: startup_stm32f10x_md.s
